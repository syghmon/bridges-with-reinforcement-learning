Commit message: stability changes

File: assembly_gym/shapes/cube.urdf (robot description, URDF)
Before this commit: robot block_t, 1 links, 0 joints
Links:
- link block_t_base_link: geometry collision box size=1.0 1.0 1.0; visual box size=1.0 1.0 1.0
